# Keil uVision project AT32.uvprojx, settings and files
target AT32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F403RCT6 ArteryTek
  pack: ArteryTek.AT32F403_DFP.2.0.6
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403ZGT6,USE_STDPERIPH_DRIVER,AT_START_F403_V1
  c include: ..\AT32moban\bsp;..\AT32moban\cmsis;..\AT32moban\firmware;..\AT32moban\user;..\AT32moban\libraries\drivers\inc;..\AT32moban\libraries\cmsis\cm4\core_support;..\AT32moban\libraries\cmsis\cm4\device_support\startup\mdk;..\AT32moban\libraries\cmsis\cm4\device_support;.\drv
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../AT32moban/user/: at32f403_clock.c at32f403_int.c main.c
  group bsp
    ../AT32moban/bsp/: at32f403_board.c
  group firmware
    ../AT32moban/firmware/: at32f403_adc.c at32f403_bpr.c at32f403_can.c at32f403_crc.c at32f403_crm.c at32f403_dac.c at32f403_debug.c at32f403_dma.c at32f403_exint.c at32f403_flash.c at32f403_gpio.c at32f403_i2c.c at32f403_misc.c at32f403_pwc.c at32f403_rtc.c at32f403_sdio.c at32f403_spi.c at32f403_tmr.c at32f403_usart.c at32f403_usb.c at32f403_wdt.c at32f403_wwdt.c at32f403_xmc.c
  group cmsis
    ../AT32moban/cmsis/: startup_at32f403.s system_at32f403.c
  group drv
    ./drv/: drv_gpio.c
